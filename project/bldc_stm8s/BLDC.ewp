# IAR project BLDC.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S903
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; board; ..\..\common; ..\..\component\motor; ..\..\component\motor\bldc; ..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BLDC.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ILINK.IlinkOutputFile: BLDC.out
  group (top)
    board/: board.c
    ./: main.c stm8s_it.c
  group Libraries
    ../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c
  group ucframe/bldc
    ../../component/motor/BLDC/: inject.c it.c mc_control.c mc_driver.c mdisply.c mswitch.c sys_config.c
    ../../component/motor/: motor.c
  group ucframe/common
    ../../common/: common.c flash.c key.c led.c mathex.c time.c
